# Keil uVision project Hello.uvproj, settings and files
target LPC2100 (ARM-ADS)
  device: LPC2101 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x400007FF) IROM(0-0x1FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Hello
  AfterMake: d:\Keil\ARM\bin40\fromelf.exe --bin -o ./obj/hello.bin ./obj/hello.axf
  AfterMake: d:\Keil\ARM\bin40\fromelf.exe --text -c -s --output=./obj/hello.lst ./obj/hello.axf
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x40000000 size 0x800
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Hello.c ram_chk.c test1.s
  group Documentation
    ./: Abstract.txt
